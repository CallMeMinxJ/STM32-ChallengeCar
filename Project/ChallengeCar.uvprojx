# Keil uVision project ChallengeCar.uvprojx, settings and files
target ChallengeCar (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ChallengeCar
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Library\Core;..\Library\Inc;..\System;..\Hardware\Adc;..\Hardware\Key;..\Hardware\Led;..\Hardware\Oled;..\Hardware\Timer;..\Control;..\Hardware\Dma
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c system_stm32f10x.c
  group Library
    ../Library/Core/: core_cm3.c
    ../Library/Src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Library/StarUp/: startup_stm32f10x_hd.s
  group Help
    ../Note/TXT/: CodeHelper.txt
  group System
    ../System/: system.c
  group Hardware
    ../Hardware/Adc/: adc.c
    ../Hardware/Key/: key.c
    ../Hardware/Led/: led.c
    ../Hardware/Oled/: oled.c
    ../Hardware/Timer/: timer.c
    ../Hardware/Dma/: dma.c
  group Control
    ../Control/: control.c menu.c
